# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\Drivers\STM32F1xx_HAL_Driver\Inc;.\Drivers\STM32F1xx_HAL_Driver\Src;.\Drivers;.\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Drivers\CMSIS\Include;.\App\Inc;.\BSP\Inc;.\Config;.\Middlewares\WiFi;.\Middlewares\Protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h Timer.c Timer.h sys.c sys.h i2c.c i2c.h usart.c usart.h myiic.c myiic.h
  group Hardware
    ./Hardware/: LED.c LED.h Key.c Key.h OLED.c OLED.h OLED_Font.h Serial.c Serial.h AD.c AD.h lm75a.c lm75a.h oled0561.c oled0561.h ASCII_8x16.h dht11.c dht11.h PWM.c PWM.h Servo.c Servo.h Motor.c Motor.h atk_oled.c atk_oled.h atk_mb026.c atk_mb026.h atk_mb026_uart.c atk_mb026_uart.h oledfont.h atk_mb026_receiver.h atk_mb026_receiver.c Serial2.c Serial2.h RS485.c RS485.h SoilSensor.c SoilSensor.h LightSensor.c LightSensor.h OLED_Display.c OLED_Display.h ServerComm.c ServerComm.h PrintManager.c PrintManager.h atk_d43.c atk_d43.h
    ./Hardware/RELAY/: relay.c
    ./Hardware/TOUCH_KEY/: touch_key.c
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h demo.c demo.h
  group App
    ./App/Src/: main.c system.c
    ./App/Inc/: system.h
  group BSP
    ./BSP/Src/: uart.c
    ./BSP/Inc/: uart.h
  group Middlewares
    ./Middlewares/WiFi/: wifi_manager.c wifi_manager.h
    ./Middlewares/Protocol/: protocol.c protocol.h
  group Config
    ./Config/: sys_config.h
